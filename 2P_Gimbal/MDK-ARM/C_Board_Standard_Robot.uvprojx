# Keil uVision project C_Board_Standard_Robot.uvprojx, settings and files
target C_Board_Standard_Robot (6160000::V6.16::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: C_Board_Standard_Robot +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__TARGET_FPU_VFP
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Bsp;../Components;../Components/Devices;../Components/Controller;../Components/Algorithm;../Components/Algorithm/Include;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../RM_Lib/Inc;../Init_Ctrl;../Agency/Gimbal;../Agency/Shoot;../Agency/WatchDog;../Agency/Data_Deal;../Agency/Serialport;../Agency/Chassis;../Agency/USB;../gimbal_ws/middlewares/motor;../gimbal_ws/middlewares/VT03;../gimbal_ws/middlewares
  asm include: ../Inc;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
    ../Components/Algorithm/: arm_cortexM4lf_math.lib
  group Application/User
    ../Src/: main.c gpio.c freertos.c can.c dma.c rng.c spi.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_rng.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Bsp
    ../Bsp/: bsp_dwt.c bsp_PWM.c bsp_rc.c bsp_buzzer.c
  group Components
    ../Components/: Variate.c Time.c kalman_filter.c user_lib.c remote_control.c
    ../Components/Algorithm/: QuaternionEKF.c
    ../Components/Devices/: BMI088driver.c BMI088Middleware.c
    ../gimbal_ws/middlewares/motor/: dm_motor.c dm_motor.h
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group RM_Lib
    ../RM_Lib/Src/: CANDrive.c motor.c PID.c ramp.c remote.c WatchDog.c CRC.c
    ../Components/Algorithm/: RMLib.lib
    ../Components/: Function.c
    ../Components/Controller/: controller.c
    ../gimbal_ws/middlewares/VT03/: VT03.c VT03.h
    ../gimbal_ws/middlewares/: Referee.h
  group Init_Ctrl
    ../Init_Ctrl/: Init_Task.c ins_task.c MainCtrl_Task.c
  group Shoot
    ../Agency/Shoot/: Shoot.c Shoot.h Shoot_Task.c
  group Gimbal
    ../Agency/Gimbal/: Gimbal.c Gimbal.h Gimbal_Task.c
  group Chassis
    ../RM_Lib/Src/: Chassis.c
    ../RM_Lib/Inc/: Chassis.h
    ../Agency/Chassis/: Chassis_Task.c
  group Serialport
    ../Agency/Serialport/: plotter.cpp plotter_task.cpp
  group WatchDog
    ../Agency/WatchDog/: Callback_Function.c Task_Music.c Music.c
  group USB
    ../Agency/USB/: USB_Task.c
software components: CMSIS:CORE 5.4.0
